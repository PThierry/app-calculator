## Kconfig
```kconfig
mainmenu "Calculator app"

config CALCULATOR_APP
    bool "enable sample app"
    default y
    select WITH_SENTRY
```
